# Keil uVision project blackbox_1.0 - 副本.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1752 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10003FFF) IROM(0-0x0FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: blackbox_1.0
  c flags: Optim=1
  c include: ..\include;..\include\board;..\include\common;..\include\drivers;..\include\system;..\include\board\lpc1752
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x4000
  group Source Group 1
    ./: startup_LPC17xx.s
  group include
    ../include/: includeall.h type.h
    ../include/board/lpc1752/: hardware_sets.h
    ../include/common/: lcd_printf.h
    ../include/drivers/: delay.h led.h uart_all.h uart0.h uart1.h w25q256.h
    ../include/system/: LPC17xx.h lpc17xx_uart.h system_LPC17xx.h
  group common
    ../common/printf/: lcd_printf.c
    ../common/system/: system_LPC17xx.c
  group drivers
    ../dirvers/delay/: delay.c
    ../dirvers/led/: led.c
    ../dirvers/serial/: uart_all.c uart0.c uart1.c
    ../dirvers/spi/w25q256/: w25q256.c
  group src
    ../src/: main.c
  group board
    ../board/lpc1752/: hardware_sets.c
