# Keil uVision project blackbox.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1752 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10003FFF) IROM(0-0x0FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: blackbox +hex
  c flags: Optim=1
  c include: ../include\;../include/board\;../include/board/lpc1752\;../include/common\;../include/drivers\;../include/system\;../include/board/test\
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x4000
  group src
    ../src/: main.c
  group driver
    ../dirvers/delay/: delay.c
    ../dirvers/led/: led.c
    ../dirvers/serial/: uart_all.c uart0.c uart1.c
    ../dirvers/timer/: CTimeDef.c timer_all.c irq_timer.c
    ../dirvers/spi/w25q256_ssp/: w25q256.c ops_w25qxx.c
    ../dirvers/usb/: usb_driver.c usb_hw.c
    ../common/: utils.c
  group common
    ../common/printf/: lcd_printf.c
    ../common/system/: system_LPC17xx.c core_cm3.c startup_LPC17xx.s
  group board
    ../board/lpc1752/: hardware_sets.c irq_manage.c
    ../board/test/: test_hw.c
  group include
    ../include/board/lpc1752/: hardware_sets.h irq_manage.h
    ../include/common/: lcd_printf.h utils.h
    ../include/drivers/: delay.h led.h uart_all.h uart0.h uart1.h CTimeDef.h irq_timer.h w25q256.h usb_driver.h usb_hw.h usbcfg.h usbreg.h ops_w25qxx.h
    ../include/system/: LPC17xx.h lpc17xx_uart.h system_LPC17xx.h
    ../include/: includeall.h type.h
    ../include/board/test/: test_hw.h
